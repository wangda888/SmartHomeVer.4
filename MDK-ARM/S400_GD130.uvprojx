# Keil uVision project S400_GD130.uvprojx, settings and files
target S400_GD130 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: GD32F130C6 GigaDevice
  pack: GigaDevice.GD32F1x0_DFP.2.0.1
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: S400_GD130 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\S400_GD130;..\Firmware\Peripherals\inc;..\Firmware\CMSIS;..\HARDWARE\LED;..\SYSTEM\sys;..\SYSTEM\delay;..\SYSTEM\usart;..\HARDWARE\EC11;..\HARDWARE\ET2259;..\Func485;..\HARDWARE\ET62429
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group User
    ../: gd32f1x0_it.c main.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/EC11/: EC11.c
    ../HARDWARE/ET2259/: ET2259.c myiic.c
    ../HARDWARE/ET62429/: ET62429.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/usart/: usart.c
  group CMSIS
    ../Firmware/CMSIS/: core_cm3.c system_gd32f1x0.c
  group GD32F1x0_Peripherals
    ../Firmware/Peripherals/src/: gd32f1x0_crc.c gd32f1x0_exti.c gd32f1x0_gpio.c gd32f1x0_misc.c gd32f1x0_rcc.c gd32f1x0_rtc.c gd32f1x0_timer.c gd32f1x0_usart.c gd32f1x0_fmc.c
  group Startup
    ../Firmware/CMSIS/: startup_gd32f1x0.s
  group Func485
    ../Func485/: Func485.c FuncAPI.c uart3.c DataSave.c
